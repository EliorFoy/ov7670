# Keil uVision project ADC.uvprojx, settings and files
target ADC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\source;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./source/: delay.c ili9320.c SCCB.c ov7670.c main.c stm32f10x_it.c
  group FWLib
    ./source/: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
software components: CMSIS:CORE 5.6.0
